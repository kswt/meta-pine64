PACKAGECONFIG:append:h6 = " kmsro panfrost"
PACKAGECONFIG:append:a64 = " lima"
