PACKAGECONFIG:append = "drm vaapi gbm egl"
